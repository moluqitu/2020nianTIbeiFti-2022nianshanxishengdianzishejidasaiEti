# Keil uVision project USART.uvprojx, settings and files
target USART (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\MLX90614;..\HARDWARE\OLED;..\HARDWARE\USART1;..\HARDWARE\EXIT1;..\HARDWARE\BEEF;..\HARDWARE\SMBUS;..\HARDWARE\DISPLAY
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/MLX90614/: mlx90614.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/EXIT1/: exit1.c
    ../HARDWARE/USART1/: usart1.c
    ../HARDWARE/BEEF/: beef.c
    ../HARDWARE/SMBUS/: smbus.c
    ../HARDWARE/DISPLAY/: display.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_sdio.c stm32f10x_wwdg.c stm32f10x_rtc.c stm32f10x_iwdg.c
  group README
    ../: README.TXT
